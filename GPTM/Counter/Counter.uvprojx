# Keil uVision project Counter.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: HT32F52352 Holtek
  pack: Holtek.HT32_DFP.1.0.10
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x1FE00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Counter
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main_gptm.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
